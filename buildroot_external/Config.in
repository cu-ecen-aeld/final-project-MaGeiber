## buildroot_external/package/alpaqa_application/Config.in
```kconfig
config BR2_PACKAGE_ALPAQA_APPLICATION
	bool "alpaqa_application"
	help
	  Includes the alpaqa executable.
```
